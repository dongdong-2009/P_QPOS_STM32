# Keil uVision project QPOSV2.1.uvproj, settings and files
target mPos_3_4_Debug (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mPOS_3_4_N +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,ROC_RTC
  c include: .\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;.\USBHID\inc;.\BlueTooth;.\Buzzer;.\SysTick;.\MSCard_PA1100;.\User;.\Audio;.\Roc;.\Z8D256;.\IROM;.\PBOC;.\HAL_7816;.\LCD;.\Cell;.\Keyboard;.\Power;.\CMD;.\RTC;.\tamper;.\iwdg;.\io_uart;.\RF\Bfl\inc;.\RF\App\inc;.\RC523;.\RSA;.\sha1
  memory RVCT4: ROM 0x8000000 size 0x3a800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c VectorTable.c
    ./tamper/: tamper.c
  group stdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group COMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./User/: system_stm32f10x.c
  group StartUp
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group MSCard_PA1100
    ./MSCard_PA1100/: MSCard_PA1100.c
  group BlueTooth
    ./BlueTooth/: BlueTooth.c
  group SysTick
    ./SysTick/: SysTick_delay.c
  group Buzzer
    ./Buzzer/: Buzzer.c
  group Roc
    ./Roc/: Roc_LittleTool.c Roc_PersonalFont.c
  group Z8D256
    ./Z8D256/: Z8D256.c Sercrity.c
  group IROM
    ./IROM/: IROM.c
  group HAL_7816
    ./HAL_7816/: HAL_7816.c
  group PBOC
    ./PBOC/: APP_PBOC.c MID_PBOC.C PBOC_Var.c
  group LCD
    ./LCD/: Display.c FontFonction.c msd.c ASCII.c lcd_gui.c
  group Keyboard
    ./Keyboard/: Key.c
  group Cell
    ./Cell/: AN_ADC.c
  group CMD
    ./CMD/: UP_MPOS_CMD.c APP_parameters.c
  group Power
    ./Power/: Pwercheck.c
  group RTC
    ./RTC/: rtc.c
  group usb_std_driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usb_hid
    ./USBHID/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbhid.c
  group iwdg
    ./iwdg/: iwdg.c
  group io_uart
    ./io_uart/: UART_simulation.C
  group RF_LIB
    ./RF/Bfl/src/: phbalReg.c phbalReg_Stub.c phCidManager.c phCidManager_Sw.c phhalHw.c phhalHw_Rc523.c phhalHw_Rc523_Cmd.c phhalHw_Rc523_Int.c phhalHw_Rc523_Wait.c phpalEpcUid.c phpalEpcUid_Sw.c phpalI14443p3a.c phpalI14443p3a_Sw.c phpalI14443p3b.c phpalI14443p3b_Sw.c phpalI14443p4.c phpalI14443p4_Sw.c phpalI14443p4a.c phpalI14443p4a_Sw.c phpalMifare.c phpalMifare_Sw.c phTools.c RegCtl_SpiHw.c
    ./RF/App/src/: nfc_main.c
  group rc523
    ./RC523/: RC523.c
  group QPBOC
    ./QPBOC/: APP_qPBOC_Pay.c offline.c
  group RSA
    ./RSA/: Rsa.c IC_interface.c
  group des
    ./DES/: des.c
target mPos_3_4_Release (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: mPOS_3_4_N_UpDate +hex
  AfterMake: c:\Keil\ARM\ARMCC\bin\fromelf.exe  --bin -o ./RVMDK/Release/mPOS_3_4_N_Update.bin ./RVMDK/Release/mPOS_3_4_N_Update.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,ROC_RTC,MPOS_UPDATE
  c include: .\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;.\USBHID\inc;.\BlueTooth;.\Buzzer;.\SysTick;.\MSCard_PA1100;.\User;.\Audio;.\Roc;.\Z8D256;.\IROM;.\PBOC;.\HAL_7816;.\LCD;.\Cell;.\Keyboard;.\Power;.\CMD;.\RTC;.\tamper;.\iwdg;.\io_uart;.\RF\Bfl\inc;.\RF\App\inc;.\RC523;.\QPBOC;.\RSA;.\DES
  memory RVCT4: ROM 0x8006000 size 0x3a000
  memory RVCT9: RAM 0x20000000 size 0xc000
